| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs4a110.ibs
[File Rev]   1.0
[Date]   February 23, 2000
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 2000 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|   Component QS4A110
[Component]   QS4A110
|Project: QSW5B
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| QSOP
R_pkg   0.01   0.01   0.01
L_pkg   2.50nH   2.50nH   2.50nH
C_pkg   0.40pF   0.40pF   0.40pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   E1B   ENABLE   NA   NA   NA
2   C0   NC   NA   NA   NA
3   A0   NC   NA   NA   NA
4   A1   NC   NA   NA   NA
5   C1   NC   NA   NA   NA
6   C2   NC   NA   NA   NA
7   A2   NC   NA   NA   NA
8   A3   NC   NA   NA   NA
9   C3   NC   NA   NA   NA
10   C4   NC   NA   NA   NA
11   A4   NC   NA   NA   NA
12   GND   GND   NA   NA   NA
|13   E2B   ENABLE   NA   NA   NA
14   B0   NC   NA   NA   NA
15   D0   NC   NA   NA   NA
16   D1   NC   NA   NA   NA
17   B1   NC   NA   NA   NA
18   B2   NC   NA   NA   NA
19   D2   NC   NA   NA   NA
20   D3   NC   NA   NA   NA
21   B3   NC   NA   NA   NA
22   B4   NC   NA   NA   NA
23   D4   NC   NA   NA   NA
24   VCC   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
3   2   QSIO   1
4   5   QSIO   2
7   6   QSIO   3
8   9   QSIO   4
11   10   QSIO   5
14   15   QSIO   6
17   16   QSIO   7
18   19   QSIO   8
21   20   QSIO   9
22   23   QSIO   10
|   Series_MOSFET   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
C_comp   5.26pF   NA   NA
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
